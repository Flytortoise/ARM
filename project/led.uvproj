# Keil uVision project led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: template
  AfterMake: fromelf.exe --bin -o output/@l.bin output/@l.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: .\Mini2451_Demo.sct
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: start.s Main.c uart.c my_printf.c time.c chinese.c ascii.c lcd.c led.c bmp.c rtc.c delay.c bmp1.c bmp2.c bmp3.c bmp4.c bmp5.c
    ./MMU/: mmu.c 2440slib.s
